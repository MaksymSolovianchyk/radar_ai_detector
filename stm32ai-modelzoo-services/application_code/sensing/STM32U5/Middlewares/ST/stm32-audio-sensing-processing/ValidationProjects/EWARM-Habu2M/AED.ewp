# IAR project AED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32U3C5ZI ST STM32U3C5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U3C5xx; USE_HSP
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Habu2M-AED\Drivers\CMSIS\DSP\Include; ..\..\..\Habu2M-AED\Drivers\CMSIS\DSP\Include\dsp; ..\..\..\Habu2M-AED\Drivers\CMSIS\Core\Include; ..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\Drivers\STM32U3xx_HAL_Driver\Inc\Legacy; ..\Core\Inc; ..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\HSP_engine\Target; ..\Middlewares\ST\hsp_engine\core; ..\Middlewares\ST\hsp_engine\interfaces; ..\Middlewares\ST\hsp_engine\modules; ..\Middlewares\ST\hsp_engine\modules\cnn_lib; ..\Middlewares\ST\hsp_engine\modules\direct_lib; ..\Middlewares\ST\hsp_engine\modules\dsp_lib; ..\Middlewares\ST\hsp_engine\modules\proclist_lib; ..\HSP_engine\App; ..\Middlewares\ST\hsp_engine\modules\firmware; ..\Testing; ..\Testing\AED
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: AED.out
  ILINK.IlinkIcfFile: C:\Users\trillinr\Documents\stm32-audio-sensing-processing\ValidationProjects\EWARM-Habu2M\stm32u3c5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U3C5xx; USE_HSP_; USE_HAL_HSP_CUBE1_LEGACY
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group Application/Core
    ../Core/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c system_stm32u3xx.c
  group Application/HSP_Engine/App
    ../HSP_engine/App/: hsp_engine.c
  group Application/HSP_Engine/Target
    ../HSP_engine/Target/: hsp_conf.c hsp_if_conf.c
  group Audio_Preprocessing
    ../../Src/: audio_din.c common_tables.c feature_extraction.c mel_filterbank.c window.c
  group Drivers/CMSIS/DSP
    ../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal2.S arm_cfft_f32.c arm_cfft_init_f32.c arm_cfft_radix8_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c arm_cmplx_mag_squared_f32.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: arm_dot_prod_f32.c arm_mult_f32.c
    ../Drivers/CMSIS/DSP/Source/SupportFunctions/: arm_q15_to_float.c
  group Drivers/STM32U3xx_HAL_Driver
    ../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_hsp.c stm32u3xx_hal_icache.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Middleware-HSP/Core
    ../Middlewares/ST/hsp_engine/core/: hsp_bram.c hsp_core.c
  group Middleware-HSP/Interfaces
    ../Middlewares/ST/hsp_engine/interfaces/: hsp_bram_if.c hsp_hw_if.c hsp_memcpy.c hsp_utilities.c
    ../Middlewares/ST/hsp_engine/interfaces/portable/IAR/: st_hsp_memcpy32.s
  group Middleware-HSP/Modules/CNN_LIB
    ../Middlewares/ST/hsp_engine/modules/cnn_lib/: hsp_cnn.c
  group Middleware-HSP/Modules/Direct_LIB
    ../Middlewares/ST/hsp_engine/modules/direct_lib/: hsp_direct_command.c
  group Middleware-HSP/Modules/Dsp_LIB
    ../Middlewares/ST/hsp_engine/modules/dsp_lib/: hsp_dsp.c
  group Middleware-HSP/Modules/Proclist_LIB
    ../Middlewares/ST/hsp_engine/modules/proclist_lib/: hsp_proclist_complex.c hsp_proclist_conditional.c hsp_proclist_filter.c hsp_proclist_matrix.c hsp_proclist_scalar.c hsp_proclist_transform.c hsp_proclist_vector.c
  group Testing
    ../Testing/: aiTestUtility.c lc_print.c test_common_functions.c
    ../Testing/AED/: LogMel_aed_hsp_test.c LogMel_aed_test_data.c preproc_dpu.c user_mel_tables.c
