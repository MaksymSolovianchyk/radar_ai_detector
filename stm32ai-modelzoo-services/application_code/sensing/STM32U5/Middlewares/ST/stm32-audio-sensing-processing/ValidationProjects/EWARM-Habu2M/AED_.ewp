# IAR project AED_.ewp, settings and files
configuration SysPerf (ARM, debug)
  General.OGChipSelectEditMenu: STM32U3C5CI ST STM32U3C5CI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U3C5xx; USE_HAL_DRIVER; USE_SYSPERF_MODE
  ICCARM.CCIncludePath2: ..\Boards\AED\Core\Inc; ..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\Drivers\STM32U3xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\Drivers\CMSIS\Core\Include; ..\Inc; ..\st_ai_output; ..\Middlewares\ST\Application\Misc\Inc; ..\Middlewares\ST\Application\SystemPerformance\Inc; ..\..\..\tools\inspector\workspace\include; ..\..\Drivers\ST_HSP\inc\Legacy; ..\..\Drivers\CMSIS\DSP\Include; ..\..\Drivers\ST_CMSIS\NN\Include; ..\Middlewares\ST\hsp_engine\interfaces; ..\Middlewares\ST\hsp_engine\modules\cnn_lib; ..\Middlewares\ST\hsp_engine\modules\direct_lib; ..\Middlewares\ST\hsp_engine\modules\firmware; ..\Middlewares\ST\hsp_engine\modules\proclist_lib; ..\Boards\AED\HSP_engine\App; ..\Boards\AED\HSP_engine\Target; ..\Middlewares\ST\hsp_engine\core; ..\Middlewares\ST\hsp_engine\modules; ..\Middlewares\ST\hsp_engine\modules\dsp_lib; ..\Boards\AED\LFBE_SWW; ..\Boards\AED\DPU; ..\Boards\AED\LFBE_AED\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AED.srec
  ILINK.IlinkOutputFile: AED.out
  ILINK.IlinkIcfFile: ..\Boards\AED\EWARM\stm32u3c5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Validation (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32U3C5xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Boards\AED\Core\Inc; ..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\Drivers\STM32U3xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\Drivers\CMSIS\Core\Include; ..\Inc; ..\st_ai_output; ..\Middlewares\ST\Application\Misc\Inc; ..\Middlewares\ST\Application\Validation\Inc; ..\..\..\tools\inspector\workspace\include; ..\..\Drivers\ST_HSP\inc\Legacy; ..\..\Drivers\CMSIS\DSP\Include; ..\..\Drivers\ST_CMSIS\NN\Include; ..\Middlewares\ST\hsp_engine\interfaces; ..\Middlewares\ST\hsp_engine\modules\cnn_lib; ..\Middlewares\ST\hsp_engine\modules\direct_lib; ..\Middlewares\ST\hsp_engine\modules\firmware; ..\Middlewares\ST\hsp_engine\modules\proclist_lib; ..\Boards\AED\HSP_engine\App; ..\Boards\AED\HSP_engine\Target; ..\Middlewares\ST\hsp_engine\core; ..\Middlewares\ST\hsp_engine\modules; ..\Middlewares\ST\hsp_engine\modules\dsp_lib; ..\Boards\AED\LFBE_SWW; ..\Boards\AED\DPU; ..\Boards\AED\LFBE_AED\Inc
configuration Lcut (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\Boards\AED\Core\Inc; ..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\Drivers\STM32U3xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\Drivers\CMSIS\Core\Include; ..\Inc; ..\st_ai_output; ..\Middlewares\ST\Application\Misc\Inc; ..\Middlewares\ST\Application\SystemPerformance\Inc; ..\..\..\tools\inspector\workspace\include; ..\..\Drivers\ST_HSP\inc\Legacy; ..\..\Drivers\CMSIS\DSP\Include; ..\..\Drivers\ST_CMSIS\NN\Include; ..\Middlewares\ST\hsp_engine\interfaces; ..\Middlewares\ST\hsp_engine\modules\cnn_lib; ..\Middlewares\ST\hsp_engine\modules\direct_lib; ..\Middlewares\ST\hsp_engine\modules\firmware; ..\Middlewares\ST\hsp_engine\modules\proclist_lib; ..\Boards\AED\HSP_engine\App; ..\Boards\AED\HSP_engine\Target; ..\Middlewares\ST\hsp_engine\core; ..\Middlewares\ST\hsp_engine\modules; ..\Middlewares\ST\hsp_engine\modules\dsp_lib; ..\Boards\AED\LFBE
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ..\Boards\AED\EWARM\stm32u3c5xx_flash_lcut.icf
  group Application/Audio_Preprocessing
    ../../Src/: audio_din.c common_tables.c dct.c feature_extraction.c mel_filterbank.c window.c
  group Application/CMSIS_DSP
    ../Boards/AED/CMSIS_DSP/: arm_bitreversal2.S arm_cfft_f32.c arm_cfft_init_f32.c arm_cfft_radix8_f32.c arm_cmplx_mag_f32.c arm_cmplx_mag_squared_f32.c arm_common_tables.c arm_const_structs.c arm_dot_prod_f32.c arm_mult_f32.c arm_q15_to_float.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
  group Application/Core
    ../Boards/AED/Core/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c system_stm32u3xx.c
  group Application/DPU
    ../Boards/AED/DPU/: preproc_dpu.c user_mel_tables.c
  group Application/HSP Engine/App
    ../Boards/AED/HSP_engine/App/: hsp_engine.c
  group Application/HSP Engine/Target
    ../Boards/AED/HSP_engine/Target/: hsp_conf.c
  group Drivers/HSP
    ../../Drivers/ST_CMSIS/NN/Source/NNSupportFunctions/st_dsp/: st_int8_fill.c
  group Drivers/STM32U3xx_HAL_Driver
    ../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_exti.c stm32u3xx_hal_gpio.c stm32u3xx_hal_hsp.c stm32u3xx_hal_icache.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c
  group Middleware/Core
    ../Middlewares/ST/hsp_engine/core/: hsp_bram.c hsp_core.c hsp_proclist.c
  group Middleware/Interfaces
    ../Middlewares/ST/hsp_engine/interfaces/: hsp_bram_if.c hsp_hw_if.c hsp_utilities.c
  group Middleware/Modules/CNN LIB
    ../Middlewares/ST/hsp_engine/modules/cnn_lib/: hsp_cnn.c
  group Middleware/Modules/Direct LIB
    ../Middlewares/ST/hsp_engine/modules/direct_lib/: hsp_direct_command.c
  group Middleware/Modules/Proclist LIB
    ../Middlewares/ST/hsp_engine/modules/proclist_lib/: hsp_proclist_scalar.c
